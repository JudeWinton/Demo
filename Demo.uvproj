# Keil uVision project Demo.uvproj, settings and files
target Demo (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Demo
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  link misc: REMOVEUNUSED
  group USER
    ./: main.c
  group DRIVER
    ./src/: fw_adc.c fw_i2c.c fw_mem.c fw_spi.c fw_sys.c fw_tim.c fw_uart.c fw_usb.c fw_util.c
